# Keil uVision project Template.uvprojx, settings and files
target Template (6120000::V6.12::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=6 v6Lang=6 v6Lto=1 wLevel=3
  c define: STM32F10X_HD
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\WARSHIP\LED;..\WARSHIP\KEY;..\WARSHIP\TFT;..\SYSTEM\ADC;..\SYSTEM\GPIO;..\SYSTEM\IIC_FullSpeed;..\SYSTEM\IIC_HighSpeed;..\SYSTEM\PWM;..\SYSTEM\RCC;..\SYSTEM\SPI;..\SYSTEM\TIMER;..\WARSHIP\OLED;..\WARSHIP\W25Q128;..\WARSHIP\NRF24L01;..\SYSTEM\MyUart;..\WARSHIP\ESP8266_AT;..\WARSHIP\RGB;..\WARSHIP\Encoder;..\WARSHIP\MPU6050\eMPL;..\WARSHIP\MPU6050;..\WARSHIP\TimeKeeper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\OBJ\Template.sct
  group USER
    ./: startup_stm32f10x_hd.s main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/ADC/: ADC.c
    ../SYSTEM/GPIO/: GPIO.c
    ../SYSTEM/IIC_FullSpeed/: F_IIC.c
    ../SYSTEM/IIC_HighSpeed/: H_IIC.c
    ../SYSTEM/PWM/: PWM.c
    ../SYSTEM/RCC/: RCC.c
    ../SYSTEM/SPI/: SPI.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/MyUart/: MyUart.c
  group WARSHIP
    ../WARSHIP/LED/: LED.C
    ../WARSHIP/KEY/: key.c
    ../WARSHIP/TFT/: LCD.c
    ../WARSHIP/OLED/: oled.c
    ../WARSHIP/W25Q128/: W25Q128.c
    ../WARSHIP/NRF24L01/: NRF24L01.c
    ../WARSHIP/ESP8266_AT/: ESP8266_AT.c
    ../WARSHIP/RGB/: RGB.c
    ../WARSHIP/Encoder/: Encoder.c
    ../WARSHIP/TimeKeeper/: TimeKeeper.c
  group MPU6050
    ../WARSHIP/MPU6050/: MPU6050.c
    ../WARSHIP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.1.2
